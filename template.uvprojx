# Keil uVision project template.uvprojx, settings and files
target rt-thread_stm32f412zg (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F412ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x40000) IROM(0x8000000,0x100000) CPUTYPE("Cortex-M4") FPU0 CLOCK(12000000) ELITTLE
  output: rt-thread_stm32f412zg +hex
  AfterMake: fromelf --bin !L --output @H.bin
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\rtthread_stm32.sct
